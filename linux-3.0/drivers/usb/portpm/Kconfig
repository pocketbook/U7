## linux-3.0/drivers/usb/portpm/Kconfig
```kconfig
config USB_PORT_POWER_MANAGEMENT
	tristate "Usb Port Power Management"
	depends on USB_SUPPORT
	help
		Usb Port Power Management
```
